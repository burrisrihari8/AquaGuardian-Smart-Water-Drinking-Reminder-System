# Keil uVision project AquaGuardian-Smart-Water-Drinking-Reminder-System.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: AquaGuardian-Smart-Water-Drinking-Reminder-System +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s buzzer.c display.c hydration.c interrupts_test.c kpm_new.c lcd.c led.c main_dly.c reminder.c rtc_main.c switch.c test_1.c
